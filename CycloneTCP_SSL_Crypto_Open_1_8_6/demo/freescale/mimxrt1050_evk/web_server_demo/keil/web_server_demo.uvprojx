# Keil uVision project web_server_demo.uvprojx, settings and files
target web_server_demo_flash (ARM-ADS)
  device: MIMXRT1052:M7 NXP
  pack: NXP.iMXRT_DFP.1.0.2
  cpu: IRAM(0x20000000,0x00060000) IRAM2(0x00000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: web_server_demo_flash
  BeforeMake: ..\..\..\..\..\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\src\res.c
  AfterMake: fromelf.exe --bincombined --output "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: CPU_MIMXRT1052DVL6A SKIP_SYSCLK_INIT SDRAM_MPU_INIT USE_MIMXRT1050_EVK
  c misc: --diag_suppress=66
  c include: ..\src;..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\third_party\freescale\devices\mimxrt1052;..\..\..\..\..\third_party\freescale\devices\mimxrt1052\drivers;..\..\..\..\..\third_party\freescale\boards\mimxrt1050_evk;..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\third_party\freertos\portable\rvds\arm_cm7\r0p1;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_ssl;..\..\..\..\..\cyclone_crypto
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\mimxrt1052_flash.sct
  group Demo Sources
    ./: startup_mimxrt1052.s retarget.c
    ../src/: system_mimxrt1052.c main.c debug.c res.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h FreeRTOSConfig.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c path.c resource_manager.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h path.h resource_manager.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c nic.c ethernet.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c bsd_socket.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: mimxrt1052_eth_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: ksz8081_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c ipv4.c ipv4_frag.c icmp.c igmp.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_misc.c ipv6_pmtu.c icmpv6.c mld.c ndp.c ndp_cache.c ndp_misc.c slaac.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/http/: http_server.c http_server_auth.c http_server_misc.c mime.c ssi.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h nic.h ethernet.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h bsd_socket.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: mimxrt1052_eth_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: ksz8081_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h ipv4.h ipv4_frag.h icmp.h igmp.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_misc.h ipv6_pmtu.h icmpv6.h mld.h ndp.h ndp_cache.h ndp_misc.h slaac.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/http/: http_server.h http_server_auth.h http_server_misc.h mime.h ssi.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/rvds/arm_cm7/r0p1/: port.c
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/rvds/arm_cm7/r0p1/: portmacro.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group MIMXRT1050-EVK Headers
    ../../../../../third_party/freescale/boards/mimxrt1050_evk/: mimxrt1050_evk.h
  group MIMXRT1052 Drivers Sources
    ../../../../../third_party/freescale/devices/mimxrt1052/drivers/: fsl_clock.c fsl_common.c fsl_gpio.c fsl_lpuart.c fsl_semc.c
  group MIMXRT1052 Drivers Headers
    ../../../../../third_party/freescale/devices/mimxrt1052/drivers/: fsl_clock.h fsl_common.h fsl_gpio.h fsl_iomuxc.h fsl_lpuart.h fsl_semc.h
target web_server_demo_sram (ARM-ADS)
  device: MIMXRT1052:M7 NXP
  pack: NXP.iMXRT_DFP.1.0.2
  cpu: as above
  output: web_server_demo_sram
  BeforeMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: as above
  c misc: --diag_suppress=66
  c include: as above
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\mimxrt1052_sram.sct
target web_server_demo_sdram (ARM-ADS)
  device: MIMXRT1052:M7 NXP
  pack: NXP.iMXRT_DFP.1.0.2
  cpu: as above
  output: web_server_demo_sdram
  BeforeMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: as above
  c misc: --diag_suppress=66
  c include: as above
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\mimxrt1052_sdram.sct
