# Keil uVision project ftp_client_demo.uvproj, settings and files
target ftp_client_demo_flash (ARM-ADS)
  device: LPC4337 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: ftp_client_demo_flash
  c flags: Optim=1 OneElfS=1
  c define: LPC4330 USE_LPCXPRESSO_4337 CMSIS_BITPOSITIONS
  c include: ..\src;..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\third_party\nxp\devices\lpc43xx;..\..\..\..\..\third_party\nxp\boards\common;..\..\..\..\..\third_party\nxp\boards\lpcxpresso_4337;..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\third_party\freertos\portable\rvds\arm_cm4f;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_ssl;..\..\..\..\..\cyclone_crypto
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\lpc4337_flash.sct
  group Demo Sources
    ./: startup_lpc43xx.s retarget.c
    ../src/: system_lpc43xx.c main.c debug.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h FreeRTOSConfig.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c nic.c ethernet.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c bsd_socket.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: lpc43xx_eth_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: lan8720_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c ipv4.c ipv4_frag.c icmp.c igmp.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_misc.c ipv6_pmtu.c icmpv6.c mld.c ndp.c ndp_cache.c ndp_misc.c slaac.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/ftp/: ftp_client.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h nic.h ethernet.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h bsd_socket.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: lpc43xx_eth_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: lan8720_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h ipv4.h ipv4_frag.h icmp.h igmp.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_misc.h ipv6_pmtu.h icmpv6.h mld.h ndp.h ndp_cache.h ndp_misc.h slaac.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/ftp/: ftp_client.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/rvds/arm_cm4f/: port.c
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/rvds/arm_cm4f/: portmacro.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group LPCXpresso4337 Headers
    ../../../../../third_party/nxp/boards/lpcxpresso_4337/: lpcxpresso_4337.h
target ftp_client_demo_sram (ARM-ADS)
  device: LPC4337 NXP
  cpu: as above
  output: ftp_client_demo_sram
  c flags: Optim=1 OneElfS=1
  c define: LPC4330 USE_LPCXPRESSO_4337 CMSIS_BITPOSITIONS
  c include: as above
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\lpc4337_sram.sct
