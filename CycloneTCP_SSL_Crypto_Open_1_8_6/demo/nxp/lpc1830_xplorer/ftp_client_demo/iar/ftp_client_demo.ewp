# IAR project ftp_client_demo.ewp, settings and files
configuration SPIFI (ARM, debug)
  General.OGChipSelectEditMenu: LPC1830 NXP LPC1830
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: LPC1830; USE_LPC1830_XPLORER; CMSIS_BITPOSITIONS
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\..\third_party\cmsis\include; ..\..\..\..\..\third_party\nxp\devices\lpc18xx; ..\..\..\..\..\third_party\nxp\boards\common; ..\..\..\..\..\third_party\nxp\boards\lpc1830_xplorer; ..\..\..\..\..\third_party\freertos\include; ..\..\..\..\..\third_party\freertos\portable\iar\arm_cm3; ..\..\..\..\..\common; ..\..\..\..\..\cyclone_tcp; ..\..\..\..\..\cyclone_ssl; ..\..\..\..\..\cyclone_crypto
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: LPC1830; USE_LPC1830_XPLORER; CMSIS_BITPOSITIONS
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ftp_client_demo.srec
  ILINK.IlinkOutputFile: ftp_client_demo.out
  ILINK.IlinkIcfFile: lpc1830_spifi.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SRAM (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: lpc1830_sram.icf
  group Demo Sources
    ./: startup_lpc18xx.s
    ../src/: system_lpc18xx.c main.c debug.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h FreeRTOSConfig.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c nic.c ethernet.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c bsd_socket.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: lpc18xx_eth_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: lan8720_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c ipv4.c ipv4_frag.c icmp.c igmp.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_misc.c ipv6_pmtu.c icmpv6.c mld.c ndp.c ndp_cache.c ndp_misc.c slaac.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/ftp/: ftp_client.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h nic.h ethernet.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h bsd_socket.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: lpc18xx_eth_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: lan8720_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h ipv4.h ipv4_frag.h icmp.h igmp.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_misc.h ipv6_pmtu.h icmpv6.h mld.h ndp.h ndp_cache.h ndp_misc.h slaac.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/ftp/: ftp_client.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/iar/arm_cm3/: port.c portasm.s
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/iar/arm_cm3/: portmacro.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group LPC1830-Xplorer Headers
    ../../../../../third_party/nxp/boards/lpc1830_xplorer/: lpc1830_xplorer.h
