# IAR project ftp_client_demo.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F563NB R5F563NB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x10000
  ICCRX.CCDefines: RX63NB; USE_RDK_RX63N
  ICCRX.CCIncludePath2: ..\src; ..\..\..\..\..\third_party\renesas\boards\rdk_rx63n; ..\..\..\..\..\third_party\freertos\include; ..\..\..\..\..\third_party\freertos\portable\iar\rx600; ..\..\..\..\..\common; ..\..\..\..\..\cyclone_tcp; ..\..\..\..\..\cyclone_ssl; ..\..\..\..\..\cyclone_crypto
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: ..\src
  ILINK.IlinkOutputFile: ftp_client_demo.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RX)
  as the first configuration, except:
  group Demo Sources
    ../src/: low_level_init.c main.c debug.c ext_int_driver.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h FreeRTOSConfig.h ext_int_driver.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c nic.c ethernet.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c bsd_socket.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: rx63n_eth_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: dp83620_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c ipv4.c ipv4_frag.c icmp.c igmp.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_misc.c ipv6_pmtu.c icmpv6.c mld.c ndp.c ndp_cache.c ndp_misc.c slaac.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/ftp/: ftp_client.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h nic.h ethernet.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h bsd_socket.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: rx63n_eth_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: dp83620_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h ipv4.h ipv4_frag.h icmp.h igmp.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_misc.h ipv6_pmtu.h icmpv6.h mld.h ndp.h ndp_cache.h ndp_misc.h slaac.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/ftp/: ftp_client.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/iar/rx600/: port.c port_asm.s
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/iar/rx600/: portmacro.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group RDK RX63N Sources
    ../../../../../third_party/renesas/boards/rdk_rx63n/: hwsetup.c lcd.c switches.c glyph.c r_glyph.c r_glyph_register.c r_rspi_rx600.c st7579_lcd.c font_8x8.c
  group RDK RX63N Headers
    ../../../../../third_party/renesas/boards/rdk_rx63n/: yrdkrx63n.h mcu_info.h hwsetup.h lcd.h switches.h glyph.h glyph_config.h glyph_preamble.h r_glyph.h r_glyph_config.h r_rspi_rx600.h r_rspi_rx600_config.h st7579_lcd.h
