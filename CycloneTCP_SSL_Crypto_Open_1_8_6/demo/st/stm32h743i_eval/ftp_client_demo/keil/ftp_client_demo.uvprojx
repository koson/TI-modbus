# Keil uVision project ftp_client_demo.uvprojx, settings and files
target ftp_client_demo_flash (ARM-ADS)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: ftp_client_demo_flash
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32H743xx USE_STM32H743I_EVAL USE_HAL_DRIVER USE_IOEXPANDER
  c include: ..\src;..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\third_party\st\devices\stm32h7xx;..\..\..\..\..\third_party\st\boards;..\..\..\..\..\third_party\st\boards\common;..\..\..\..\..\third_party\st\boards\stm32h743i_eval;..\..\..\..\..\third_party\st\stm32h7xx_hal_driver\inc;..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\third_party\freertos\portable\rvds\arm_cm7\r0p1;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_ssl;..\..\..\..\..\cyclone_crypto
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h743_flash.sct
  group Demo Sources
    ./: startup_stm32h743xx.s retarget.c
    ../src/: system_stm32h7xx.c stm32h7xx_it.c main.c debug.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h FreeRTOSConfig.h stm32h7xx_hal_conf.h stm32h7xx_it.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c nic.c ethernet.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c bsd_socket.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: stm32h7xx_eth_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: lan8742_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c ipv4.c ipv4_frag.c icmp.c igmp.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_misc.c ipv6_pmtu.c icmpv6.c mld.c ndp.c ndp_cache.c ndp_misc.c slaac.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/ftp/: ftp_client.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h nic.h ethernet.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h bsd_socket.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: stm32h7xx_eth_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: lan8742_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h ipv4.h ipv4_frag.h icmp.h igmp.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_misc.h ipv6_pmtu.h icmpv6.h mld.h ndp.h ndp_cache.h ndp_misc.h slaac.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/ftp/: ftp_client.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/rvds/arm_cm7/r0p1/: port.c
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/rvds/arm_cm7/r0p1/: portmacro.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group STM32H743I-EVAL Sources
    ../../../../../third_party/st/boards/stm32h743i_eval/: stm32h743i_eval.c stm32h743i_eval_eeprom.c stm32h743i_eval_io.c stm32h743i_eval_lcd.c stm32h743i_eval_nor.c stm32h743i_eval_qspi.c stm32h743i_eval_sd.c stm32h743i_eval_sdram.c stm32h743i_eval_sram.c stm32h743i_eval_ts.c
    ../../../../../third_party/st/boards/components/exc7200/: exc7200.c
    ../../../../../third_party/st/boards/components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../third_party/st/boards/components/stmpe811/: stmpe811.c
    ../../../../../third_party/st/boards/components/ts3510/: ts3510.c
  group STM32H743I-EVAL Headers
    ../../../../../third_party/st/boards/stm32h743i_eval/: stm32h743i_eval.h stm32h743i_eval_eeprom.h stm32h743i_eval_io.h stm32h743i_eval_lcd.h stm32h743i_eval_nor.h stm32h743i_eval_qspi.h stm32h743i_eval_sd.h stm32h743i_eval_sdram.h stm32h743i_eval_sram.h stm32h743i_eval_ts.h
    ../../../../../third_party/st/boards/components/exc7200/: exc7200.h
    ../../../../../third_party/st/boards/components/mfxstm32l152/: mfxstm32l152.h
    ../../../../../third_party/st/boards/components/stmpe811/: stmpe811.h
    ../../../../../third_party/st/boards/components/ts3510/: ts3510.h
  group STM32H7xx HAL Drivers Sources
    ../../../../../third_party/st/stm32h7xx_hal_driver/src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sdram.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c
  group STM32H7xx HAL Drivers Headers
    ../../../../../third_party/st/stm32h7xx_hal_driver/inc/: stm32h7xx_hal.h stm32h7xx_hal_adc.h stm32h7xx_hal_adc_ex.h stm32h7xx_hal_cec.h stm32h7xx_hal_comp.h stm32h7xx_hal_cortex.h stm32h7xx_hal_crc.h stm32h7xx_hal_crc_ex.h stm32h7xx_hal_cryp.h stm32h7xx_hal_cryp_ex.h stm32h7xx_hal_dac.h stm32h7xx_hal_dac_ex.h stm32h7xx_hal_dcmi.h stm32h7xx_hal_def.h stm32h7xx_hal_dfsdm.h stm32h7xx_hal_dma.h stm32h7xx_hal_dma_ex.h stm32h7xx_hal_dma2d.h stm32h7xx_hal_fdcan.h stm32h7xx_hal_flash.h stm32h7xx_hal_flash_ex.h stm32h7xx_hal_gpio.h stm32h7xx_hal_gpio_ex.h stm32h7xx_hal_hash.h stm32h7xx_hal_hash_ex.h stm32h7xx_hal_hcd.h stm32h7xx_hal_hrtim.h stm32h7xx_hal_hsem.h stm32h7xx_hal_i2c.h stm32h7xx_hal_i2c_ex.h stm32h7xx_hal_i2s.h stm32h7xx_hal_i2s_ex.h stm32h7xx_hal_irda.h stm32h7xx_hal_irda_ex.h stm32h7xx_hal_iwdg.h stm32h7xx_hal_jpeg.h stm32h7xx_hal_lptim.h stm32h7xx_hal_ltdc.h stm32h7xx_hal_mdios.h stm32h7xx_hal_mdma.h stm32h7xx_hal_mmc.h stm32h7xx_hal_mmc_ex.h stm32h7xx_hal_nand.h stm32h7xx_hal_nor.h stm32h7xx_hal_opamp.h stm32h7xx_hal_opamp_ex.h stm32h7xx_hal_pcd.h stm32h7xx_hal_pcd_ex.h stm32h7xx_hal_pwr.h stm32h7xx_hal_pwr_ex.h stm32h7xx_hal_qspi.h stm32h7xx_hal_rcc.h stm32h7xx_hal_rcc_ex.h stm32h7xx_hal_rng.h stm32h7xx_hal_rtc.h stm32h7xx_hal_rtc_ex.h stm32h7xx_hal_sai.h stm32h7xx_hal_sai_ex.h stm32h7xx_hal_sd.h stm32h7xx_hal_sdram.h stm32h7xx_hal_sd_ex.h stm32h7xx_hal_smartcard.h stm32h7xx_hal_smartcard_ex.h stm32h7xx_hal_smbus.h stm32h7xx_hal_spdifrx.h stm32h7xx_hal_spi.h stm32h7xx_hal_sram.h stm32h7xx_hal_swpmi.h stm32h7xx_hal_tim.h stm32h7xx_hal_tim_ex.h stm32h7xx_hal_uart.h stm32h7xx_hal_uart_ex.h stm32h7xx_hal_usart.h stm32h7xx_hal_usart_ex.h stm32h7xx_hal_wwdg.h stm32h7xx_ll_delayblock.h stm32h7xx_ll_fmc.h stm32h7xx_ll_sdmmc.h stm32h7xx_ll_usb.h
target ftp_client_demo_sram (ARM-ADS)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.1.0.1
  cpu: as above
  output: ftp_client_demo_sram
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h743_sram.sct
