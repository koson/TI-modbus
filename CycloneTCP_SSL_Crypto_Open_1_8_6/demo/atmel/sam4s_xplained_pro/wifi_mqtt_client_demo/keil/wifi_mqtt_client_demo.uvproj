# Keil uVision project wifi_mqtt_client_demo.uvproj, settings and files
target wifi_mqtt_client_demo_flash (ARM-ADS)
  device: SAM4SD32C Atmel
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0x400000-0x4FFFFF) IROM2(0x500000-0x5FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")
  output: wifi_mqtt_client_demo_flash
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: __SAM4SD32C__ USE_SAM4S_XPLAINED_PRO
  c include: ..\src;..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\third_party\atmel\devices\sam4s;..\..\..\..\..\third_party\atmel\devices\winc1500;..\..\..\..\..\third_party\atmel\boards\common;..\..\..\..\..\third_party\atmel\boards\sam4s_xplained_pro;..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\third_party\freertos\portable\rvds\arm_cm3;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_ssl;..\..\..\..\..\cyclone_crypto
  memory RVCT4: ROM 0x400000 size 0x100000
  memory RVCT5: ROM 0x500000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: .\sam4s_flash.sct
  group Demo Sources
    ./: startup_sam4s.s retarget.c
    ../src/: system_sam4s.c main.c debug.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h tls_config.h crypto_config.h FreeRTOSConfig.h winc1500_config.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c nic.c ethernet.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c bsd_socket.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/wifi/: winc1500_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c ipv4.c ipv4_frag.c icmp.c igmp.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_misc.c ipv6_pmtu.c icmpv6.c mld.c ndp.c ndp_cache.c ndp_misc.c slaac.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/mqtt/: mqtt_client.c mqtt_client_misc.c mqtt_client_packet.c mqtt_client_transport.c
    ../../../../../cyclone_tcp/web_socket/: web_socket.c web_socket_auth.c web_socket_frame.c web_socket_misc.c web_socket_transport.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h nic.h ethernet.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h bsd_socket.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/wifi/: winc1500_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h ipv4.h ipv4_frag.h icmp.h igmp.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_misc.h ipv6_pmtu.h icmpv6.h mld.h ndp.h ndp_cache.h ndp_misc.h slaac.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/mqtt/: mqtt_client.h mqtt_client_misc.h mqtt_client_packet.h mqtt_client_transport.h mqtt_common.h
    ../../../../../cyclone_tcp/web_socket/: web_socket.h web_socket_auth.h web_socket_frame.h web_socket_misc.h web_socket_transport.h
  group CycloneSSL Sources
    ../../../../../cyclone_ssl/: tls.c tls_cipher_suites.c tls_handshake.c tls_handshake_hash.c tls_handshake_misc.c tls_client.c tls_client_misc.c tls_server.c tls_server_misc.c tls_common.c tls_record.c tls_signature.c tls_certificate.c tls_key_material.c tls_cache.c tls_misc.c ssl_misc.c
  group CycloneSSL Headers
    ../../../../../cyclone_ssl/: tls.h tls_cipher_suites.h tls_handshake.h tls_handshake_hash.h tls_handshake_misc.h tls_client.h tls_client_misc.h tls_server.h tls_server_misc.h tls_common.h tls_record.h tls_signature.h tls_certificate.h tls_key_material.h tls_cache.h tls_misc.h ssl_misc.h
  group CycloneCrypto Sources
    ../../../../../cyclone_crypto/hash/: md5.c sha1.c sha224.c sha256.c sha384.c sha512.c
    ../../../../../cyclone_crypto/mac/: hmac.c poly1305.c
    ../../../../../cyclone_crypto/cipher/: rc4.c idea.c des.c des3.c aes.c camellia.c seed.c aria.c chacha.c
    ../../../../../cyclone_crypto/cipher_mode/: cbc.c
    ../../../../../cyclone_crypto/aead/: ccm.c gcm.c chacha20_poly1305.c
    ../../../../../cyclone_crypto/pkc/: dh.c rsa.c dsa.c
    ../../../../../cyclone_crypto/ecc/: ec.c ec_curves.c ecdh.c ecdsa.c curve25519.c curve448.c x25519.c x448.c
    ../../../../../cyclone_crypto/mpi/: mpi.c
    ../../../../../cyclone_crypto/encoding/: base64.c asn1.c oid.c
    ../../../../../cyclone_crypto/certificate/: pem_import.c x509_cert_parse.c x509_cert_validate.c x509_common.c
    ../../../../../cyclone_crypto/rng/: yarrow.c
  group CycloneCrypto Headers
    ../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../cyclone_crypto/hash/: md5.h sha1.h sha224.h sha256.h sha384.h sha512.h
    ../../../../../cyclone_crypto/mac/: hmac.h poly1305.h
    ../../../../../cyclone_crypto/cipher/: rc4.h idea.h des.h des3.h aes.h camellia.h seed.h aria.h chacha.h
    ../../../../../cyclone_crypto/cipher_mode/: cbc.h
    ../../../../../cyclone_crypto/aead/: ccm.h gcm.h chacha20_poly1305.h
    ../../../../../cyclone_crypto/pkc/: dh.h rsa.h dsa.h
    ../../../../../cyclone_crypto/ecc/: ec.h ec_curves.h ecdh.h ecdsa.h curve25519.h curve448.h x25519.h x448.h
    ../../../../../cyclone_crypto/mpi/: mpi.h
    ../../../../../cyclone_crypto/encoding/: base64.h asn1.h oid.h
    ../../../../../cyclone_crypto/certificate/: pem_import.h x509_cert_parse.h x509_cert_validate.h x509_common.h
    ../../../../../cyclone_crypto/rng/: yarrow.h
  group WINC1500 BSP Sources
    ../../../../../third_party/atmel/devices/winc1500/bsp/source/: nm_bsp_sam4s.c
    ../../../../../third_party/atmel/devices/winc1500/bus_wrapper/source/: nm_bus_wrapper_sam4s.c
  group WINC1500 BSP Headers
    ../../../../../third_party/atmel/devices/winc1500/bsp/include/: nm_bsp.h nm_bsp_internal.h nm_bsp_sam4s.h
    ../../../../../third_party/atmel/devices/winc1500/bus_wrapper/include/: nm_bus_wrapper.h
  group WINC1500 Driver Sources
    ../../../../../third_party/atmel/devices/winc1500/common/source/: nm_common.c
    ../../../../../third_party/atmel/devices/winc1500/driver/source/: m2m_ate_mode.c m2m_crypto.c m2m_hif.c m2m_ota.c m2m_periph.c m2m_wifi.c nmasic.c nmbus.c nmdrv.c nmi2c.c nmspi.c nmuart.c
    ../../../../../third_party/atmel/devices/winc1500/spi_flash/source/: spi_flash.c
  group WINC1500 Driver Headers
    ../../../../../third_party/atmel/devices/winc1500/common/include/: nm_common.h nm_debug.h
    ../../../../../third_party/atmel/devices/winc1500/driver/include/: m2m_ate_mode.h m2m_crypto.h m2m_ota.h m2m_periph.h m2m_types.h m2m_wifi.h
    ../../../../../third_party/atmel/devices/winc1500/driver/source/: m2m_hif.h nmasic.h nmbus.h nmi2c.h nmdrv.h nmspi.h nmuart.h
    ../../../../../third_party/atmel/devices/winc1500/spi_flash/include/: spi_flash.h spi_flash_map.h
    ../../../../../third_party/atmel/devices/winc1500/socket/include/: m2m_socket_host_if.h
  group WINC1500 OS Support Source
    ../../../../../third_party/atmel/devices/winc1500/os/source/: m2m_wifi_ex.c
  group WINC1500 OS Support Headers
    ../../../../../third_party/atmel/devices/winc1500/os/include/: m2m_wifi_ex.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/rvds/arm_cm3/: port.c
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/rvds/arm_cm3/: portmacro.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group SAM4S-Xplained-Pro Headers
    ../../../../../third_party/atmel/boards/sam4s_xplained_pro/: sam4s_xplained_pro.h
target wifi_mqtt_client_demo_sram (ARM-ADS)
  device: SAM4SD32C Atmel
  cpu: as above
  output: wifi_mqtt_client_demo_sram
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: __SAM4SD32C__ USE_SAM4S_XPLAINED_PRO
  c include: as above
  memory RVCT4: ROM 0x400000 size 0x100000
  memory RVCT5: ROM 0x500000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: .\sam4s_sram.sct
