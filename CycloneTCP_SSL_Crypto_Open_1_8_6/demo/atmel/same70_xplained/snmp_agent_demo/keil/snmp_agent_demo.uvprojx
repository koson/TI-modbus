# Keil uVision project snmp_agent_demo.uvprojx, settings and files
target snmp_agent_demo_flash (ARM-ADS)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.0
  cpu: IROM(0x00400000,0x00200000) IROM2(0x00800000,0x00004000) IRAM(0x20400000,0x00060000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: snmp_agent_demo_flash
  c flags: Optim=1 OneElfS=1
  c define: __SAME70Q21__ USE_SAME70_XPLAINED
  c include: ..\src;..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\third_party\atmel\devices\same70;..\..\..\..\..\third_party\atmel\boards\common;..\..\..\..\..\third_party\atmel\boards\same70_xplained;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_ssl;..\..\..\..\..\cyclone_crypto
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT5: ROM 0x800000 size 0x4000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: .\same70_flash.sct
  group Demo Sources
    ./: startup_same70.s same70_gpnvm.s retarget.c
    ../src/: system_same70.c main.c private_mib_module.c private_mib_impl.c debug.c ext_int_driver.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h crypto_config.h private_mib_module.h private_mib_impl.h ext_int_driver.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_none.c date_time.c str.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_none.h date_time.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c nic.c ethernet.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c bsd_socket.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: same70_eth_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: ksz8081_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c ipv4.c ipv4_frag.c icmp.c igmp.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_misc.c ipv6_pmtu.c icmpv6.c mld.c ndp.c ndp_cache.c ndp_misc.c slaac.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/snmp/: snmp_agent.c snmp_agent_dispatch.c snmp_agent_message.c snmp_agent_pdu.c snmp_agent_object.c snmp_agent_trap.c snmp_agent_inform.c snmp_agent_usm.c snmp_agent_vacm.c snmp_agent_misc.c
    ../../../../../cyclone_tcp/mibs/: mib_common.c mib2_module.c mib2_impl.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h nic.h ethernet.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h bsd_socket.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: same70_eth_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: ksz8081_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h ipv4.h ipv4_frag.h icmp.h igmp.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_misc.h ipv6_pmtu.h icmpv6.h mld.h ndp.h ndp_cache.h ndp_misc.h slaac.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/snmp/: snmp_agent.h snmp_agent_dispatch.h snmp_agent_message.h snmp_agent_pdu.h snmp_agent_object.h snmp_agent_trap.h snmp_agent_inform.h snmp_agent_usm.h snmp_agent_vacm.h snmp_agent_misc.h snmp_common.h
    ../../../../../cyclone_tcp/mibs/: mib_common.h mib2_module.h mib2_impl.h
  group CycloneCrypto Sources
    ../../../../../cyclone_crypto/hash/: md5.c sha1.c
    ../../../../../cyclone_crypto/mac/: hmac.c
    ../../../../../cyclone_crypto/cipher/: des.c aes.c
    ../../../../../cyclone_crypto/cipher_mode/: cbc.c cfb.c
    ../../../../../cyclone_crypto/encoding/: asn1.c oid.c
  group CycloneCrypto Headers
    ../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../cyclone_crypto/hash/: md5.h sha1.h
    ../../../../../cyclone_crypto/mac/: hmac.h
    ../../../../../cyclone_crypto/cipher/: des.h aes.h
    ../../../../../cyclone_crypto/cipher_mode/: cbc.h cfb.h
    ../../../../../cyclone_crypto/encoding/: asn1.h oid.h
  group SAME70-Xplained Source
    ../../../../../third_party/atmel/boards/same70_xplained/: sdram.c
  group SAME70-Xplained Headers
    ../../../../../third_party/atmel/boards/same70_xplained/: same70_xplained.h sdram.h
target snmp_agent_demo_sram (ARM-ADS)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.0
  cpu: as above
  output: snmp_agent_demo_sram
  c flags: Optim=1 OneElfS=1
  c define: __SAME70Q21__ USE_SAME70_XPLAINED
  c include: as above
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT5: ROM 0x800000 size 0x4000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: .\same70_sram.sct
