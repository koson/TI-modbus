# IAR project web_server_demo.ewp, settings and files
configuration DDRAM (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D35 Atmel ATSAMA5D35
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: SAMA5D36; USE_SAMA5D3_XPLAINED
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\..\third_party\atmel\devices\sama5d3x; ..\..\..\..\..\third_party\atmel\boards\sama5d3_xplained; ..\..\..\..\..\third_party\freertos\include; ..\..\..\..\..\third_party\freertos\portable\iar\arm_ca5_no_gic; ..\..\..\..\..\common; ..\..\..\..\..\cyclone_tcp; ..\..\..\..\..\cyclone_ssl; ..\..\..\..\..\cyclone_crypto
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: SAMA5D36; USE_SAMA5D3_XPLAINED
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: web_server_demo.srec
  prebuild: ..\..\..\..\..\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\src\res.c
  ILINK.IlinkOutputFile: web_server_demo.out
  ILINK.IlinkIcfFile: sama5d3x_ddram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration SRAM (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: sama5d3x_sram.icf
configuration NOR FLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: sama5d3x_norflash.icf
  group Demo Sources
    ./: board_cstartup_iar.s cp15_asm_iar.s
    ../src/: board_lowlevel.c board_memories.c aic.c cp15.c mmu.c pit.c pmc.c wdt.c main.c freertos_tick_config.c freertos_irq_handler.c debug.c res.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h tls_config.h crypto_config.h FreeRTOSConfig.h board_lowlevel.h cp15.h irq.h mmu.h pit.h pmc.h wdt.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c path.c resource_manager.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h path.h resource_manager.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c nic.c ethernet.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c bsd_socket.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: sama5d3_eth_driver.c sama5d3_gigabit_eth_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: ksz8081_driver.c ksz9031_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c ipv4.c ipv4_frag.c icmp.c igmp.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_misc.c ipv6_pmtu.c icmpv6.c mld.c ndp.c ndp_cache.c ndp_misc.c slaac.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/http/: http_server.c http_server_auth.c http_server_misc.c mime.c ssi.c
    ../../../../../cyclone_tcp/smtp/: smtp_client.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h nic.h ethernet.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h bsd_socket.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: sama5d3_eth_driver.h sama5d3_gigabit_eth_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: ksz8081_driver.h ksz9031_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h ipv4.h ipv4_frag.h icmp.h igmp.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_misc.h ipv6_pmtu.h icmpv6.h mld.h ndp.h ndp_cache.h ndp_misc.h slaac.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/http/: http_server.h http_server_auth.h http_server_misc.h mime.h ssi.h
    ../../../../../cyclone_tcp/smtp/: smtp_client.h
  group CycloneSSL Sources
    ../../../../../cyclone_ssl/: tls.c tls_cipher_suites.c tls_handshake.c tls_handshake_hash.c tls_handshake_misc.c tls_client.c tls_client_misc.c tls_server.c tls_server_misc.c tls_common.c tls_record.c tls_signature.c tls_certificate.c tls_key_material.c tls_cache.c tls_misc.c ssl_misc.c
  group CycloneSSL Headers
    ../../../../../cyclone_ssl/: tls.h tls_cipher_suites.h tls_handshake.h tls_handshake_hash.h tls_handshake_misc.h tls_client.h tls_client_misc.h tls_server.h tls_server_misc.h tls_common.h tls_record.h tls_signature.h tls_certificate.h tls_key_material.h tls_cache.h tls_misc.h ssl_misc.h
  group CycloneCrypto Sources
    ../../../../../cyclone_crypto/hash/: md5.c sha1.c sha224.c sha256.c sha384.c sha512.c
    ../../../../../cyclone_crypto/mac/: hmac.c poly1305.c
    ../../../../../cyclone_crypto/cipher/: rc4.c idea.c des.c des3.c aes.c camellia.c seed.c aria.c chacha.c
    ../../../../../cyclone_crypto/cipher_mode/: cbc.c
    ../../../../../cyclone_crypto/aead/: ccm.c gcm.c chacha20_poly1305.c
    ../../../../../cyclone_crypto/pkc/: dh.c rsa.c dsa.c
    ../../../../../cyclone_crypto/ecc/: ec.c ec_curves.c ecdh.c ecdsa.c curve25519.c curve448.c x25519.c x448.c
    ../../../../../cyclone_crypto/mpi/: mpi.c
    ../../../../../cyclone_crypto/encoding/: base64.c asn1.c oid.c
    ../../../../../cyclone_crypto/certificate/: pem_import.c x509_cert_parse.c x509_cert_validate.c x509_common.c
    ../../../../../cyclone_crypto/rng/: yarrow.c
  group CycloneCrypto Headers
    ../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../cyclone_crypto/hash/: md5.h sha1.h sha224.h sha256.h sha384.h sha512.h
    ../../../../../cyclone_crypto/mac/: hmac.h poly1305.h
    ../../../../../cyclone_crypto/cipher/: rc4.h idea.h des.h des3.h aes.h camellia.h seed.h aria.h chacha.h
    ../../../../../cyclone_crypto/cipher_mode/: cbc.h
    ../../../../../cyclone_crypto/aead/: ccm.h gcm.h chacha20_poly1305.h
    ../../../../../cyclone_crypto/pkc/: dh.h rsa.h dsa.h
    ../../../../../cyclone_crypto/ecc/: ec.h ec_curves.h ecdh.h ecdsa.h curve25519.h curve448.h x25519.h x448.h
    ../../../../../cyclone_crypto/mpi/: mpi.h
    ../../../../../cyclone_crypto/encoding/: base64.h asn1.h oid.h
    ../../../../../cyclone_crypto/certificate/: pem_import.h x509_cert_parse.h x509_cert_validate.h x509_common.h
    ../../../../../cyclone_crypto/rng/: yarrow.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/iar/arm_ca5_no_gic/: port.c portasm.s
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/iar/arm_ca5_no_gic/: portmacro.h portasm.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group SAMA5D3-Xplained Headers
    ../../../../../third_party/atmel/boards/sama5d3_xplained/: sama5d3_xplained.h
