# IAR project web_server_demo.ewp, settings and files
configuration DDRAM (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Atmel SAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: VARIANT_DDRAM; CONFIG_CORE_CORTEXA5; CONFIG_SOC_SAMA5; CONFIG_SOC_SAMA5D2; CONFIG_SOC_SAMA5D27; CONFIG_BOARD_SAMA5D2_XPLAINED; CONFIG_HAVE_AIC5; CONFIG_HAVE_FLEXCOM; CONFIG_HAVE_PIO4; CONFIG_HAVE_QSPI; CONFIG_HAVE_MCAN; CONFIG_HAVE_SDMMC; CONFIG_HAVE_PMIC_ACT8945A; CONFIG_HAVE_USART_FIFO; CONFIG_HAVE_USART_LIN; CONFIG_HAVE_SPI_FIFO; CONFIG_HAVE_TWI_FIFO; CONFIG_HAVE_GMAC_QUEUES; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_DATA_PATH; CONFIG_HAVE_MPDDRC_IO_CALIBRATION; CONFIG_HAVE_MPDDRC_DDR2; CONFIG_HAVE_MPDDRC_LPDDR2; CONFIG_HAVE_MPDDRC_DDR3; CONFIG_HAVE_MPDDRC_LPDDR3; CONFIG_HAVE_TWI_ALTERNATE_CMD; CONFIG_HAVE_ADC_SETTLING_TIME; CONFIG_HAVE_ADC_INPUT_OFFSET; CONFIG_HAVE_ADC_INPUT_GAIN; CONFIG_HAVE_ADC_SEQ_R2; CONFIG_HAVE_PMC_FAST_STARTUP; CONFIG_HAVE_PMC_GENERATED_CLOCKS; CONFIG_HAVE_PMC_AUDIO_CLOCK; CONFIG_HAVE_PMC_PCK2; CONFIG_HAVE_PWM_DMA; CONFIG_HAVE_PWM_SPREAD_SPECTRUM; CONFIG_HAVE_PWM_EXTERNAL_TRIGGER; CONFIG_HAVE_PWM_FAULT_PROT_HIZ; CONFIG_HAVE_PWM_STEPPER_MOTOR; CONFIG_HAVE_SFRBU; CONFIG_HAVE_L2CC; CONFIG_HAVE_SAIC; CONFIG_HAVE_L2CC; CONFIG_HAVE_XDMAC; CONFIG_HAVE_ADC; CONFIG_HAVE_SHA; CONFIG_HAVE_TRNG; CONFIG_HAVE_ETH; CONFIG_HAVE_GMAC; CONFIG_HAVE_CLASSD; CONFIG_HAVE_PDMIC; CONFIG_HAVE_SSC; CONFIG_HAVE_SFC; CONFIG_HAVE_AUDIO; CONFIG_HAVE_PWMC; CONFIG_HAVE_SECURE_MATRIX; CONFIG_HAVE_DDR3_MT41K128M16; CONFIG_HAVE_RSTC_CONFIGURABLE_USER_RESET; CONFIG_HAVE_TC_FAULT_MODE; CONFIG_HAVE_RTC_CALIBRATION; CONFIG_HAVE_RTC_TAMPER
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\..\third_party\atmel\devices\sama5d2x; ..\..\..\..\..\third_party\atmel\devices\sama5d2x\drivers; ..\..\..\..\..\third_party\atmel\devices\sama5d2x\drivers\core; ..\..\..\..\..\third_party\atmel\devices\sama5d2x\lib; ..\..\..\..\..\third_party\atmel\devices\sama5d2x\utils; ..\..\..\..\..\third_party\atmel\boards\sama5d2_xplained_ultra; ..\..\..\..\..\third_party\freertos\include; ..\..\..\..\..\third_party\freertos\portable\iar\arm_ca5_no_gic; ..\..\..\..\..\common; ..\..\..\..\..\cyclone_tcp; ..\..\..\..\..\cyclone_ssl; ..\..\..\..\..\cyclone_crypto
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: web_server_demo.srec
  prebuild: ..\..\..\..\..\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\src\res.c
  ILINK.IlinkOutputFile: web_server_demo.out
  ILINK.IlinkIcfFile: sama5d2x_ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SRAM (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: sama5d2x_sram.icf
  group Demo Sources
    ./: cstartup.s
    ../src/: main.c freertos_tick_config.c freertos_irq_handler.c debug.c res.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h tls_config.h crypto_config.h FreeRTOSConfig.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c path.c resource_manager.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h path.h resource_manager.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c nic.c ethernet.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c bsd_socket.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: sama5d2_eth_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: ksz8081_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c ipv4.c ipv4_frag.c icmp.c igmp.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_misc.c ipv6_pmtu.c icmpv6.c mld.c ndp.c ndp_cache.c ndp_misc.c slaac.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/http/: http_server.c http_server_auth.c http_server_misc.c mime.c ssi.c
    ../../../../../cyclone_tcp/smtp/: smtp_client.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h nic.h ethernet.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h bsd_socket.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: sama5d2_eth_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: ksz8081_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h ipv4.h ipv4_frag.h icmp.h igmp.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_misc.h ipv6_pmtu.h icmpv6.h mld.h ndp.h ndp_cache.h ndp_misc.h slaac.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/http/: http_server.h http_server_auth.h http_server_misc.h mime.h ssi.h
    ../../../../../cyclone_tcp/smtp/: smtp_client.h
  group CycloneSSL Sources
    ../../../../../cyclone_ssl/: tls.c tls_cipher_suites.c tls_handshake.c tls_handshake_hash.c tls_handshake_misc.c tls_client.c tls_client_misc.c tls_server.c tls_server_misc.c tls_common.c tls_record.c tls_signature.c tls_certificate.c tls_key_material.c tls_cache.c tls_misc.c ssl_misc.c
  group CycloneSSL Headers
    ../../../../../cyclone_ssl/: tls.h tls_cipher_suites.h tls_handshake.h tls_handshake_hash.h tls_handshake_misc.h tls_client.h tls_client_misc.h tls_server.h tls_server_misc.h tls_common.h tls_record.h tls_signature.h tls_certificate.h tls_key_material.h tls_cache.h tls_misc.h ssl_misc.h
  group CycloneCrypto Sources
    ../../../../../cyclone_crypto/hash/: md5.c sha1.c sha224.c sha256.c sha384.c sha512.c
    ../../../../../cyclone_crypto/mac/: hmac.c poly1305.c
    ../../../../../cyclone_crypto/cipher/: rc4.c idea.c des.c des3.c aes.c camellia.c seed.c aria.c chacha.c
    ../../../../../cyclone_crypto/cipher_mode/: cbc.c
    ../../../../../cyclone_crypto/aead/: ccm.c gcm.c chacha20_poly1305.c
    ../../../../../cyclone_crypto/pkc/: dh.c rsa.c dsa.c
    ../../../../../cyclone_crypto/ecc/: ec.c ec_curves.c ecdh.c ecdsa.c curve25519.c curve448.c x25519.c x448.c
    ../../../../../cyclone_crypto/mpi/: mpi.c
    ../../../../../cyclone_crypto/encoding/: base64.c asn1.c oid.c
    ../../../../../cyclone_crypto/certificate/: pem_import.c x509_cert_parse.c x509_cert_validate.c x509_common.c
    ../../../../../cyclone_crypto/rng/: yarrow.c
  group CycloneCrypto Headers
    ../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../cyclone_crypto/hash/: md5.h sha1.h sha224.h sha256.h sha384.h sha512.h
    ../../../../../cyclone_crypto/mac/: hmac.h poly1305.h
    ../../../../../cyclone_crypto/cipher/: rc4.h idea.h des.h des3.h aes.h camellia.h seed.h aria.h chacha.h
    ../../../../../cyclone_crypto/cipher_mode/: cbc.h
    ../../../../../cyclone_crypto/aead/: ccm.h gcm.h chacha20_poly1305.h
    ../../../../../cyclone_crypto/pkc/: dh.h rsa.h dsa.h
    ../../../../../cyclone_crypto/ecc/: ec.h ec_curves.h ecdh.h ecdsa.h curve25519.h curve448.h x25519.h x448.h
    ../../../../../cyclone_crypto/mpi/: mpi.h
    ../../../../../cyclone_crypto/encoding/: base64.h asn1.h oid.h
    ../../../../../cyclone_crypto/certificate/: pem_import.h x509_cert_parse.h x509_cert_validate.h x509_common.h
    ../../../../../cyclone_crypto/rng/: yarrow.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/iar/arm_ca5_no_gic/: port.c portasm.s
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/iar/arm_ca5_no_gic/: portmacro.h portasm.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group SAMA5D2 Drivers Sources
    ../../../../../third_party/atmel/devices/sama5d2x/drivers/core/: arm_cp15.c arm_cp15_pmu.c arm_cpsr.c arm_interrupts.c arm_mmu.c
    ../../../../../third_party/atmel/devices/sama5d2x/drivers/misc/: cache.c
    ../../../../../third_party/atmel/devices/sama5d2x/drivers/memories/: ddram.c
    ../../../../../third_party/atmel/devices/sama5d2x/drivers/power/: act8945a.c
    ../../../../../third_party/atmel/devices/sama5d2x/drivers/peripherals/: acc.c adc.c aic5.c classd.c dma.c flexcom.c hsmc.c icm.c l2cc.c matrix.c mcan.c mpddrc.c pdmic.c pio4.c pit.c pmc.c pwmc.c qspi.c rstc.c rtc.c sdmmc.c secumod.c sfc.c sfrbu.c sha.c shdwc.c spi.c spid.c ssc.c tc.c tdes.c trng.c twi.c twid.c uart.c usart.c usartd.c usart_iso7816_4.c usart_lin.c wdt.c xdmac.c xdmad.c
  group SAMA5D2 Drivers Headers
    ../../../../../third_party/atmel/devices/sama5d2x/drivers/core/: arm.h arm_cp15.h arm_cp15_pmu.h arm_cpsr.h arm_interrupts.h arm_mmu.h
    ../../../../../third_party/atmel/devices/sama5d2x/drivers/misc/: cache.h
    ../../../../../third_party/atmel/devices/sama5d2x/drivers/memories/: ddram.h
    ../../../../../third_party/atmel/devices/sama5d2x/drivers/power/: act8945a.h
    ../../../../../third_party/atmel/devices/sama5d2x/drivers/peripherals/: acc.h adc.h aes.h aesb.h aic.h classd.h dbgu.h dma.h dmac.h dmacd.h emac.h emacd.h ethd.h flexcom.h gmac.h gmacd.h hsmc.h hsmcic.h hsmcid.h icm.h isc.h isi.h l2cc.h matrix.h mcan.h mpddrc.h pdmic.h pio.h pio3.h pio4.h pit.h pmc.h pmecc.h pmecc_gf_512.h pmecc_gf_1024.h pwmc.h qspi.h rstc.h rtc.h sdmmc.h secumod.h sfc.h sfrbu.h sha.h shdwc.h spi.h spid.h ssc.h tc.h tdes.h trng.h twi.h twid.h uart.h usart.h usartd.h usart_iso7816_4.h usart_lin.h wdt.h xdmac.h xdmad.h
  group SAMA5D2 Utils Sources
    ../../../../../third_party/atmel/devices/sama5d2x/: chip.c
    ../../../../../third_party/atmel/devices/sama5d2x/utils/: mutex.c mutex_armv7_iar.s timer.c trace.c
  group SAMA5D2 Utils Headers
    ../../../../../third_party/atmel/devices/sama5d2x/: chip.h
    ../../../../../third_party/atmel/devices/sama5d2x/utils/: compiler.h intmath.h io.h mutex.h timer.h trace.h
  group SAMA5D2-Xplained-Ultra Sources
    ../../../../../third_party/atmel/boards/sama5d2_xplained_ultra/: board_support.c board_sama5d2-xplained.c
  group SAMA5D2-Xplained-Ultra Headers
    ../../../../../third_party/atmel/boards/sama5d2_xplained_ultra/: board.h board_support.h board_sama5d2-xplained.h
